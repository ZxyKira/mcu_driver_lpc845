# Keil uVision project mcu_driver_lpc845.uvprojx, settings and files
target Library (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC845M301JBD64 NXP
  pack: Keil.LPC800_DFP.1.10.1
  cpu: IRAM(0x10000000,0x00004000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: mcu_driver_lpc845 (library)
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: NDEBUG, CPU_LPC845M301JBD64
  c include: ..\import;..\include;..\source
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x4000
  group import
    ../import/: system_LPC845.c
  group include
    ../include/: fsl_acomp.h fsl_adc.h fsl_capt.h fsl_clock.h fsl_common.h fsl_crc.h fsl_ctimer.h fsl_dac.h fsl_device_registers.h fsl_dma.h fsl_gpio.h fsl_i2c.h fsl_iap.h fsl_inputmux.h fsl_inputmux_connections.h fsl_iocon.h fsl_mrt.h fsl_pint.h fsl_power.h fsl_reset.h fsl_sctimer.h fsl_spi.h fsl_swm.h fsl_swm_connections.h fsl_syscon.h fsl_syscon_connections.h fsl_usart.h fsl_wkt.h fsl_wwdt.h LPC845.h LPC845_features.h system_LPC845.h
  group source
    ../source/: fsl_acomp.c fsl_adc.c fsl_capt.c fsl_clock.c fsl_common.c fsl_crc.c fsl_ctimer.c fsl_dac.c fsl_dma.c fsl_gpio.c fsl_i2c.c fsl_iap.c fsl_inputmux.c fsl_mrt.c fsl_pint.c fsl_power.c fsl_reset.c fsl_sctimer.c fsl_spi.c fsl_swm.c fsl_syscon.c fsl_usart.c fsl_wkt.c fsl_wwdt.c
